## boards/shields/smcboard/Kconfig.defconfig
```kconfig
if SHIELD_SMCBOARD

config ZMK_KEYBOARD_NAME
    default "smcboard"

config SPI
	default y

config GPIO_MCP23SXX
	default y
endif
```
